# Autodesk Inventor part: magazin spring
## iProperties
Created: 2006-04
Part Number: magazin spring
Document SubType Name: Modeling
Designer: Калинин
Author: Калинин
## Feature names
1. Сдвиг1
