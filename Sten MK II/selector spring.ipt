# Autodesk Inventor part: selector spring
## iProperties
Created: 2006-04
Part Number: selector spring
Document SubType Name: Modeling
Designer: Калинин
Author: Калинин
## Feature names
1. Пружина1
