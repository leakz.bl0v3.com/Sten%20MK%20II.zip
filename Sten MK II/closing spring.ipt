# Autodesk Inventor part: closing spring
## iProperties
Created: 2006-04
Part Number: closing spring
Document SubType Name: Modeling
Designer: Калинин
Author: Калинин
## Feature names
1. Пружина1
